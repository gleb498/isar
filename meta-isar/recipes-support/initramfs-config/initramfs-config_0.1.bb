#
# Copyright (C) Siemens ag, 2020
#
# SPDX-License-Identifier: MIT

require recipes-support/initramfs-config/initramfs-config.inc

